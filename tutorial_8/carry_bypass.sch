v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -190 -50 -70 -50 {lab=Cin}
N -100 -70 -70 -70 {lab=B0}
N -100 90 -60 90 {lab=B0}
N -90 -90 -90 70 {lab=A0}
N -90 70 -60 70 {lab=A0}
N -120 30 -20 30 {lab=#net1}
N -70 0 -20 0 {lab=#net2}
N -70 0 -70 130 {lab=#net2}
N -70 130 -20 130 {lab=#net2}
N -150 -90 -70 -90 {lab=A0}
N -130 -130 -20 -130 {lab=#net1}
N -130 -130 -130 30 {lab=#net1}
N -130 30 -120 30 {lab=#net1}
N -110 -70 -110 90 {lab=B0}
N -110 90 -100 90 {lab=B0}
N 110 -70 140 -70 {lab=B1}
N 110 90 150 90 {lab=B1}
N 120 -90 120 70 {lab=A1}
N 120 70 150 70 {lab=A1}
N 90 30 190 30 {lab=#net1}
N 140 0 190 0 {lab=#net2}
N 140 0 140 130 {lab=#net2}
N 140 130 190 130 {lab=#net2}
N 60 -90 140 -90 {lab=A1}
N 80 -130 190 -130 {lab=#net1}
N 80 -130 80 30 {lab=#net1}
N 80 30 90 30 {lab=#net1}
N 100 -70 100 90 {lab=B1}
N 100 90 110 90 {lab=B1}
N 60 -70 110 -70 {lab=B1}
N -150 -70 -100 -70 {lab=B0}
N -20 -130 80 -130 {lab=#net1}
N -20 130 140 130 {lab=#net2}
N 30 -60 30 -50 {lab=#net3}
N 30 -50 140 -50 {lab=#net3}
N 320 -70 350 -70 {lab=B2}
N 320 90 360 90 {lab=B2}
N 330 -90 330 70 {lab=A2}
N 330 70 360 70 {lab=A2}
N 300 30 400 30 {lab=#net1}
N 350 0 400 0 {lab=#net2}
N 350 0 350 130 {lab=#net2}
N 350 130 400 130 {lab=#net2}
N 270 -90 350 -90 {lab=A2}
N 290 -130 400 -130 {lab=#net1}
N 290 -130 290 30 {lab=#net1}
N 290 30 300 30 {lab=#net1}
N 310 -70 310 90 {lab=B2}
N 310 90 320 90 {lab=B2}
N 530 -70 560 -70 {lab=B3}
N 530 90 570 90 {lab=B3}
N 540 -90 540 70 {lab=A3}
N 540 70 570 70 {lab=A3}
N 510 30 610 30 {lab=#net1}
N 560 0 610 0 {lab=#net2}
N 560 0 560 130 {lab=#net2}
N 560 130 610 130 {lab=#net2}
N 480 -90 560 -90 {lab=A3}
N 500 -130 610 -130 {lab=#net1}
N 500 -130 500 30 {lab=#net1}
N 500 30 510 30 {lab=#net1}
N 520 -70 520 90 {lab=B3}
N 520 90 530 90 {lab=B3}
N 480 -70 530 -70 {lab=B3}
N 270 -70 320 -70 {lab=B2}
N 400 -130 500 -130 {lab=#net1}
N 400 130 560 130 {lab=#net2}
N 450 -60 450 -50 {lab=#net4}
N 450 -50 560 -50 {lab=#net4}
N 190 -130 290 -130 {lab=#net1}
N 190 130 350 130 {lab=#net2}
N 240 -60 240 -50 {lab=#net5}
N 240 -50 350 -50 {lab=#net5}
N 660 -60 660 -50 {lab=#net6}
N 660 -50 690 -50 {lab=#net6}
N 610 -130 720 -130 {lab=#net1}
N 930 -70 950 -70 {lab=#net2}
N 950 -70 950 20 {lab=#net2}
N 610 20 750 20 {lab=#net2}
N 610 -0 610 20 {lab=#net2}
N 690 -50 850 -50 {lab=#net6}
N 750 20 910 20 {lab=#net2}
N 720 -130 880 -130 {lab=#net1}
N 820 -30 890 -30 {lab=Cin}
N 660 80 660 140 {lab=#net7}
N 660 140 680 140 {lab=#net7}
N 450 80 450 160 {lab=#net8}
N 450 160 680 160 {lab=#net8}
N 240 180 680 180 {lab=#net9}
N 240 80 240 180 {lab=#net9}
N 40 200 680 200 {lab=#net10}
N 30 200 40 200 {lab=#net10}
N 30 80 30 200 {lab=#net10}
N 610 130 610 240 {lab=#net2}
N 610 240 730 240 {lab=#net2}
N 610 30 730 30 {lab=#net1}
N 730 30 730 100 {lab=#net1}
N 790 170 820 170 {lab=#net11}
N 730 100 860 100 {lab=#net1}
N 860 100 860 130 {lab=#net1}
N 860 210 860 240 {lab=#net2}
N 730 240 860 240 {lab=#net2}
N 930 0 930 170 {lab=#net12}
N 910 170 930 170 {lab=#net12}
N 910 20 950 20 {lab=#net2}
N 850 -50 890 -50 {lab=#net6}
N 880 -130 920 -130 {lab=#net1}
N 920 -130 920 -80 {lab=#net1}
N 1040 -40 1160 -40 {lab=#net13}
N 1130 -60 1160 -60 {lab=B4}
N 1130 100 1170 100 {lab=B4}
N 1140 -80 1140 80 {lab=A4}
N 1140 80 1170 80 {lab=A4}
N 1110 40 1210 40 {lab=#net14}
N 1160 10 1210 10 {lab=#net15}
N 1160 10 1160 140 {lab=#net15}
N 1160 140 1210 140 {lab=#net15}
N 1080 -80 1160 -80 {lab=A4}
N 1100 -120 1210 -120 {lab=#net14}
N 1100 -120 1100 40 {lab=#net14}
N 1100 40 1110 40 {lab=#net14}
N 1120 -60 1120 100 {lab=B4}
N 1120 100 1130 100 {lab=B4}
N 1340 -60 1370 -60 {lab=B5}
N 1340 100 1380 100 {lab=B5}
N 1350 -80 1350 80 {lab=A5}
N 1350 80 1380 80 {lab=A5}
N 1320 40 1420 40 {lab=#net14}
N 1370 10 1420 10 {lab=#net15}
N 1370 10 1370 140 {lab=#net15}
N 1370 140 1420 140 {lab=#net15}
N 1290 -80 1370 -80 {lab=A5}
N 1310 -120 1420 -120 {lab=#net14}
N 1310 -120 1310 40 {lab=#net14}
N 1310 40 1320 40 {lab=#net14}
N 1330 -60 1330 100 {lab=B5}
N 1330 100 1340 100 {lab=B5}
N 1290 -60 1340 -60 {lab=B5}
N 1080 -60 1130 -60 {lab=B4}
N 1210 -120 1310 -120 {lab=#net14}
N 1210 140 1370 140 {lab=#net15}
N 1260 -50 1260 -40 {lab=#net16}
N 1260 -40 1370 -40 {lab=#net16}
N 1550 -60 1580 -60 {lab=B6}
N 1550 100 1590 100 {lab=B6}
N 1560 -80 1560 80 {lab=A6}
N 1560 80 1590 80 {lab=A6}
N 1530 40 1630 40 {lab=#net14}
N 1580 10 1630 10 {lab=#net15}
N 1580 10 1580 140 {lab=#net15}
N 1580 140 1630 140 {lab=#net15}
N 1500 -80 1580 -80 {lab=A6}
N 1520 -120 1630 -120 {lab=#net14}
N 1520 -120 1520 40 {lab=#net14}
N 1520 40 1530 40 {lab=#net14}
N 1540 -60 1540 100 {lab=B6}
N 1540 100 1550 100 {lab=B6}
N 1760 -60 1790 -60 {lab=B7}
N 1760 100 1800 100 {lab=B7}
N 1770 -80 1770 80 {lab=A7}
N 1770 80 1800 80 {lab=A7}
N 1740 40 1840 40 {lab=#net14}
N 1790 10 1840 10 {lab=#net15}
N 1790 10 1790 140 {lab=#net15}
N 1790 140 1840 140 {lab=#net15}
N 1710 -80 1790 -80 {lab=A7}
N 1730 -120 1840 -120 {lab=#net14}
N 1730 -120 1730 40 {lab=#net14}
N 1730 40 1740 40 {lab=#net14}
N 1750 -60 1750 100 {lab=B7}
N 1750 100 1760 100 {lab=B7}
N 1710 -60 1760 -60 {lab=B7}
N 1500 -60 1550 -60 {lab=B6}
N 1630 -120 1730 -120 {lab=#net14}
N 1630 140 1790 140 {lab=#net15}
N 1680 -50 1680 -40 {lab=#net17}
N 1680 -40 1790 -40 {lab=#net17}
N 1420 -120 1520 -120 {lab=#net14}
N 1420 140 1580 140 {lab=#net15}
N 1470 -50 1470 -40 {lab=#net18}
N 1470 -40 1580 -40 {lab=#net18}
N 1890 -50 1890 -40 {lab=#net19}
N 1890 -40 1920 -40 {lab=#net19}
N 1840 -120 1950 -120 {lab=#net14}
N 2160 -60 2180 -60 {lab=#net15}
N 2180 -60 2180 30 {lab=#net15}
N 1840 30 1980 30 {lab=#net15}
N 1840 10 1840 30 {lab=#net15}
N 1920 -40 2080 -40 {lab=#net19}
N 1980 30 2140 30 {lab=#net15}
N 1950 -120 2110 -120 {lab=#net14}
N 2050 -20 2120 -20 {lab=Cin}
N 1890 90 1890 150 {lab=#net20}
N 1890 150 1910 150 {lab=#net20}
N 1680 90 1680 170 {lab=#net21}
N 1680 170 1910 170 {lab=#net21}
N 1470 190 1910 190 {lab=#net22}
N 1470 90 1470 190 {lab=#net22}
N 1270 210 1910 210 {lab=#net23}
N 1260 210 1270 210 {lab=#net23}
N 1260 90 1260 210 {lab=#net23}
N 1840 140 1840 250 {lab=#net15}
N 1840 250 1960 250 {lab=#net15}
N 1840 40 1960 40 {lab=#net14}
N 1960 40 1960 110 {lab=#net14}
N 2020 180 2050 180 {lab=#net24}
N 1960 110 2090 110 {lab=#net14}
N 2090 110 2090 140 {lab=#net14}
N 2090 220 2090 250 {lab=#net15}
N 1960 250 2090 250 {lab=#net15}
N 2160 10 2160 180 {lab=#net25}
N 2140 180 2160 180 {lab=#net25}
N 2140 30 2180 30 {lab=#net15}
N 2080 -40 2120 -40 {lab=#net19}
N 2110 -120 2150 -120 {lab=#net14}
N 2150 -120 2150 -70 {lab=#net14}
N 960 -40 1040 -40 {lab=#net13}
N 2230 -30 2350 -30 {lab=#net26}
N 2320 -50 2350 -50 {lab=B8}
N 2320 110 2360 110 {lab=B8}
N 2330 -70 2330 90 {lab=A8}
N 2330 90 2360 90 {lab=A8}
N 2300 50 2400 50 {lab=#net27}
N 2350 20 2400 20 {lab=#net28}
N 2350 20 2350 150 {lab=#net28}
N 2350 150 2400 150 {lab=#net28}
N 2270 -70 2350 -70 {lab=A8}
N 2290 -110 2400 -110 {lab=#net27}
N 2290 -110 2290 50 {lab=#net27}
N 2290 50 2300 50 {lab=#net27}
N 2310 -50 2310 110 {lab=B8}
N 2310 110 2320 110 {lab=B8}
N 2530 -50 2560 -50 {lab=B9}
N 2530 110 2570 110 {lab=B9}
N 2540 -70 2540 90 {lab=A9}
N 2540 90 2570 90 {lab=A9}
N 2510 50 2610 50 {lab=#net27}
N 2560 20 2610 20 {lab=#net28}
N 2560 20 2560 150 {lab=#net28}
N 2560 150 2610 150 {lab=#net28}
N 2480 -70 2560 -70 {lab=A9}
N 2500 -110 2610 -110 {lab=#net27}
N 2500 -110 2500 50 {lab=#net27}
N 2500 50 2510 50 {lab=#net27}
N 2520 -50 2520 110 {lab=B9}
N 2520 110 2530 110 {lab=B9}
N 2480 -50 2530 -50 {lab=B9}
N 2270 -50 2320 -50 {lab=B8}
N 2400 -110 2500 -110 {lab=#net27}
N 2400 150 2560 150 {lab=#net28}
N 2450 -40 2450 -30 {lab=#net29}
N 2450 -30 2560 -30 {lab=#net29}
N 2740 -50 2770 -50 {lab=B10}
N 2740 110 2780 110 {lab=B10}
N 2750 -70 2750 90 {lab=A10}
N 2750 90 2780 90 {lab=A10}
N 2720 50 2820 50 {lab=#net27}
N 2770 20 2820 20 {lab=#net28}
N 2770 20 2770 150 {lab=#net28}
N 2770 150 2820 150 {lab=#net28}
N 2690 -70 2770 -70 {lab=A10}
N 2710 -110 2820 -110 {lab=#net27}
N 2710 -110 2710 50 {lab=#net27}
N 2710 50 2720 50 {lab=#net27}
N 2730 -50 2730 110 {lab=B10}
N 2730 110 2740 110 {lab=B10}
N 2950 -50 2980 -50 {lab=B11}
N 2950 110 2990 110 {lab=B11}
N 2960 -70 2960 90 {lab=A11}
N 2960 90 2990 90 {lab=A11}
N 2930 50 3030 50 {lab=#net27}
N 2980 20 3030 20 {lab=#net28}
N 2980 20 2980 150 {lab=#net28}
N 2980 150 3030 150 {lab=#net28}
N 2900 -70 2980 -70 {lab=A11}
N 2920 -110 3030 -110 {lab=#net27}
N 2920 -110 2920 50 {lab=#net27}
N 2920 50 2930 50 {lab=#net27}
N 2940 -50 2940 110 {lab=B11}
N 2940 110 2950 110 {lab=B11}
N 2900 -50 2950 -50 {lab=B11}
N 2690 -50 2740 -50 {lab=B10}
N 2820 -110 2920 -110 {lab=#net27}
N 2820 150 2980 150 {lab=#net28}
N 2870 -40 2870 -30 {lab=#net30}
N 2870 -30 2980 -30 {lab=#net30}
N 2610 -110 2710 -110 {lab=#net27}
N 2610 150 2770 150 {lab=#net28}
N 2660 -40 2660 -30 {lab=#net31}
N 2660 -30 2770 -30 {lab=#net31}
N 3080 -40 3080 -30 {lab=#net32}
N 3080 -30 3110 -30 {lab=#net32}
N 3030 -110 3140 -110 {lab=#net27}
N 3350 -50 3370 -50 {lab=#net28}
N 3370 -50 3370 40 {lab=#net28}
N 3030 40 3170 40 {lab=#net28}
N 3030 20 3030 40 {lab=#net28}
N 3110 -30 3270 -30 {lab=#net32}
N 3170 40 3330 40 {lab=#net28}
N 3140 -110 3300 -110 {lab=#net27}
N 3240 -10 3310 -10 {lab=Cin}
N 3080 100 3080 160 {lab=#net33}
N 3080 160 3100 160 {lab=#net33}
N 2870 100 2870 180 {lab=#net34}
N 2870 180 3100 180 {lab=#net34}
N 2660 200 3100 200 {lab=#net35}
N 2660 100 2660 200 {lab=#net35}
N 2460 220 3100 220 {lab=#net36}
N 2450 220 2460 220 {lab=#net36}
N 2450 100 2450 220 {lab=#net36}
N 3030 150 3030 260 {lab=#net28}
N 3030 260 3150 260 {lab=#net28}
N 3030 50 3150 50 {lab=#net27}
N 3150 50 3150 120 {lab=#net27}
N 3210 190 3240 190 {lab=#net37}
N 3150 120 3280 120 {lab=#net27}
N 3280 120 3280 150 {lab=#net27}
N 3280 230 3280 260 {lab=#net28}
N 3150 260 3280 260 {lab=#net28}
N 3350 20 3350 190 {lab=#net38}
N 3330 190 3350 190 {lab=#net38}
N 3330 40 3370 40 {lab=#net28}
N 3270 -30 3310 -30 {lab=#net32}
N 3300 -110 3340 -110 {lab=#net27}
N 3340 -110 3340 -60 {lab=#net27}
N 3460 -20 3580 -20 {lab=#net39}
N 3550 -40 3580 -40 {lab=B12}
N 3550 120 3590 120 {lab=B12}
N 3560 -60 3560 100 {lab=A12}
N 3560 100 3590 100 {lab=A12}
N 3530 60 3630 60 {lab=#net40}
N 3580 30 3630 30 {lab=#net41}
N 3580 30 3580 160 {lab=#net41}
N 3580 160 3630 160 {lab=#net41}
N 3500 -60 3580 -60 {lab=A12}
N 3520 -100 3630 -100 {lab=#net40}
N 3520 -100 3520 60 {lab=#net40}
N 3520 60 3530 60 {lab=#net40}
N 3540 -40 3540 120 {lab=B12}
N 3540 120 3550 120 {lab=B12}
N 3760 -40 3790 -40 {lab=B13}
N 3760 120 3800 120 {lab=B13}
N 3770 -60 3770 100 {lab=A13}
N 3770 100 3800 100 {lab=A13}
N 3740 60 3840 60 {lab=#net40}
N 3790 30 3840 30 {lab=#net41}
N 3790 30 3790 160 {lab=#net41}
N 3790 160 3840 160 {lab=#net41}
N 3710 -60 3790 -60 {lab=A13}
N 3730 -100 3840 -100 {lab=#net40}
N 3730 -100 3730 60 {lab=#net40}
N 3730 60 3740 60 {lab=#net40}
N 3750 -40 3750 120 {lab=B13}
N 3750 120 3760 120 {lab=B13}
N 3710 -40 3760 -40 {lab=B13}
N 3500 -40 3550 -40 {lab=B12}
N 3630 -100 3730 -100 {lab=#net40}
N 3630 160 3790 160 {lab=#net41}
N 3680 -30 3680 -20 {lab=#net42}
N 3680 -20 3790 -20 {lab=#net42}
N 3970 -40 4000 -40 {lab=B14}
N 3970 120 4010 120 {lab=B14}
N 3980 -60 3980 100 {lab=A14}
N 3980 100 4010 100 {lab=A14}
N 3950 60 4050 60 {lab=#net40}
N 4000 30 4050 30 {lab=#net41}
N 4000 30 4000 160 {lab=#net41}
N 4000 160 4050 160 {lab=#net41}
N 3920 -60 4000 -60 {lab=A14}
N 3940 -100 4050 -100 {lab=#net40}
N 3940 -100 3940 60 {lab=#net40}
N 3940 60 3950 60 {lab=#net40}
N 3960 -40 3960 120 {lab=B14}
N 3960 120 3970 120 {lab=B14}
N 4180 -40 4210 -40 {lab=B3}
N 4180 120 4220 120 {lab=B3}
N 4190 -60 4190 100 {lab=A15}
N 4190 100 4220 100 {lab=A15}
N 4160 60 4260 60 {lab=#net40}
N 4210 30 4260 30 {lab=#net41}
N 4210 30 4210 160 {lab=#net41}
N 4210 160 4260 160 {lab=#net41}
N 4130 -60 4210 -60 {lab=A15}
N 4150 -100 4260 -100 {lab=#net40}
N 4150 -100 4150 60 {lab=#net40}
N 4150 60 4160 60 {lab=#net40}
N 4170 -40 4170 120 {lab=B3}
N 4170 120 4180 120 {lab=B3}
N 4130 -40 4180 -40 {lab=B3}
N 3920 -40 3970 -40 {lab=B14}
N 4050 -100 4150 -100 {lab=#net40}
N 4050 160 4210 160 {lab=#net41}
N 4100 -30 4100 -20 {lab=#net43}
N 4100 -20 4210 -20 {lab=#net43}
N 3840 -100 3940 -100 {lab=#net40}
N 3840 160 4000 160 {lab=#net41}
N 3890 -30 3890 -20 {lab=#net44}
N 3890 -20 4000 -20 {lab=#net44}
N 4310 -30 4310 -20 {lab=#net45}
N 4310 -20 4340 -20 {lab=#net45}
N 4260 -100 4370 -100 {lab=#net40}
N 4580 -40 4600 -40 {lab=#net41}
N 4600 -40 4600 50 {lab=#net41}
N 4260 50 4400 50 {lab=#net41}
N 4260 30 4260 50 {lab=#net41}
N 4340 -20 4500 -20 {lab=#net45}
N 4400 50 4560 50 {lab=#net41}
N 4370 -100 4530 -100 {lab=#net40}
N 4470 0 4540 0 {lab=Cin}
N 4310 110 4310 170 {lab=#net46}
N 4310 170 4330 170 {lab=#net46}
N 4100 110 4100 190 {lab=#net47}
N 4100 190 4330 190 {lab=#net47}
N 3890 210 4330 210 {lab=#net48}
N 3890 110 3890 210 {lab=#net48}
N 3690 230 4330 230 {lab=#net49}
N 3680 230 3690 230 {lab=#net49}
N 3680 110 3680 230 {lab=#net49}
N 4260 160 4260 270 {lab=#net41}
N 4260 270 4380 270 {lab=#net41}
N 4260 60 4380 60 {lab=#net40}
N 4380 60 4380 130 {lab=#net40}
N 4440 200 4470 200 {lab=#net50}
N 4380 130 4510 130 {lab=#net40}
N 4510 130 4510 160 {lab=#net40}
N 4510 240 4510 270 {lab=#net41}
N 4380 270 4510 270 {lab=#net41}
N 4580 30 4580 200 {lab=#net51}
N 4560 200 4580 200 {lab=#net51}
N 4560 50 4600 50 {lab=#net41}
N 4500 -20 4540 -20 {lab=#net45}
N 4530 -100 4570 -100 {lab=#net40}
N 4570 -100 4570 -50 {lab=#net40}
N 3380 -20 3460 -20 {lab=#net39}
N 2190 -30 2230 -30 {lab=#net26}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 80 -60 0 0 {name=x1}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 90 90 0 0 {name=x6}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 290 -60 0 0 {name=x2}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 300 90 0 0 {name=x3}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 500 -60 0 0 {name=x4}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 510 90 0 0 {name=x5}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 710 -60 0 0 {name=x7}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 720 90 0 0 {name=x8}
C {/home/EE23B038/ee5311/tutorial_8/mux2.sym} 1040 -50 0 0 {name=x9}
C {/home/EE23B038/ee5311/tutorial_8/nand4.sym} 830 170 0 0 {name=x10}
C {lab_pin.sym} 820 -30 0 0 {name=p1 sig_type=std_logic lab=Cin}
C {lab_pin.sym} -190 -50 0 0 {name=p2 sig_type=std_logic lab=Cin}
C {/home/EE23B038/ee5311/tutorial_8/inv.sym} 970 170 0 0 {name=x11}
C {lab_pin.sym} -150 -90 0 0 {name=p3 sig_type=std_logic lab=A0}
C {lab_pin.sym} -150 -70 0 0 {name=p4 sig_type=std_logic lab=B0}
C {lab_pin.sym} 60 -90 0 0 {name=p5 sig_type=std_logic lab=A1}
C {lab_pin.sym} 60 -70 0 0 {name=p6 sig_type=std_logic lab=B1}
C {lab_pin.sym} 270 -90 0 0 {name=p7 sig_type=std_logic lab=A2}
C {lab_pin.sym} 270 -70 0 0 {name=p8 sig_type=std_logic lab=B2}
C {lab_pin.sym} 480 -90 0 0 {name=p9 sig_type=std_logic lab=A3}
C {lab_pin.sym} 480 -70 0 0 {name=p10 sig_type=std_logic lab=B3}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 1310 -50 0 0 {name=x12}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 1320 100 0 0 {name=x13}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 1520 -50 0 0 {name=x14}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 1530 100 0 0 {name=x15}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 1730 -50 0 0 {name=x16}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 1740 100 0 0 {name=x17}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 1940 -50 0 0 {name=x18}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 1950 100 0 0 {name=x19}
C {/home/EE23B038/ee5311/tutorial_8/mux2.sym} 2270 -40 0 0 {name=x20}
C {/home/EE23B038/ee5311/tutorial_8/nand4.sym} 2060 180 0 0 {name=x21}
C {lab_pin.sym} 2050 -20 0 0 {name=p11 sig_type=std_logic lab=Cin}
C {/home/EE23B038/ee5311/tutorial_8/inv.sym} 2200 180 0 0 {name=x22}
C {lab_pin.sym} 1080 -80 0 0 {name=p13 sig_type=std_logic lab=A4}
C {lab_pin.sym} 1080 -60 0 0 {name=p14 sig_type=std_logic lab=B4}
C {lab_pin.sym} 1290 -80 0 0 {name=p15 sig_type=std_logic lab=A5}
C {lab_pin.sym} 1290 -60 0 0 {name=p16 sig_type=std_logic lab=B5}
C {lab_pin.sym} 1500 -80 0 0 {name=p17 sig_type=std_logic lab=A6}
C {lab_pin.sym} 1500 -60 0 0 {name=p18 sig_type=std_logic lab=B6}
C {lab_pin.sym} 1710 -80 0 0 {name=p19 sig_type=std_logic lab=A7}
C {lab_pin.sym} 1710 -60 0 0 {name=p20 sig_type=std_logic lab=B7}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 2500 -40 0 0 {name=x23}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 2510 110 0 0 {name=x24}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 2710 -40 0 0 {name=x25}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 2720 110 0 0 {name=x26}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 2920 -40 0 0 {name=x27}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 2930 110 0 0 {name=x28}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 3130 -40 0 0 {name=x29}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 3140 110 0 0 {name=x30}
C {/home/EE23B038/ee5311/tutorial_8/mux2.sym} 3460 -30 0 0 {name=x31}
C {/home/EE23B038/ee5311/tutorial_8/nand4.sym} 3250 190 0 0 {name=x32}
C {lab_pin.sym} 3240 -10 0 0 {name=p12 sig_type=std_logic lab=Cin}
C {/home/EE23B038/ee5311/tutorial_8/inv.sym} 3390 190 0 0 {name=x33}
C {lab_pin.sym} 2270 -70 0 0 {name=p22 sig_type=std_logic lab=A8}
C {lab_pin.sym} 2270 -50 0 0 {name=p23 sig_type=std_logic lab=B8}
C {lab_pin.sym} 2480 -70 0 0 {name=p24 sig_type=std_logic lab=A9}
C {lab_pin.sym} 2480 -50 0 0 {name=p25 sig_type=std_logic lab=B9}
C {lab_pin.sym} 2690 -70 0 0 {name=p26 sig_type=std_logic lab=A10}
C {lab_pin.sym} 2690 -50 0 0 {name=p27 sig_type=std_logic lab=B10}
C {lab_pin.sym} 2900 -70 0 0 {name=p28 sig_type=std_logic lab=A11}
C {lab_pin.sym} 2900 -50 0 0 {name=p29 sig_type=std_logic lab=B11}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 3730 -30 0 0 {name=x34}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 3740 120 0 0 {name=x35}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 3940 -30 0 0 {name=x36}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 3950 120 0 0 {name=x37}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 4150 -30 0 0 {name=x38}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 4160 120 0 0 {name=x39}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 4360 -30 0 0 {name=x40}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 4370 120 0 0 {name=x41}
C {/home/EE23B038/ee5311/tutorial_8/mux2.sym} 4690 -20 0 0 {name=x42}
C {/home/EE23B038/ee5311/tutorial_8/nand4.sym} 4480 200 0 0 {name=x43}
C {lab_pin.sym} 4470 0 0 0 {name=p30 sig_type=std_logic lab=Cin}
C {/home/EE23B038/ee5311/tutorial_8/inv.sym} 4620 200 0 0 {name=x44}
C {lab_pin.sym} 3500 -60 0 0 {name=p31 sig_type=std_logic lab=A12}
C {lab_pin.sym} 3500 -40 0 0 {name=p32 sig_type=std_logic lab=B12}
C {lab_pin.sym} 3710 -60 0 0 {name=p33 sig_type=std_logic lab=A13}
C {lab_pin.sym} 3710 -40 0 0 {name=p34 sig_type=std_logic lab=B13}
C {lab_pin.sym} 3920 -60 0 0 {name=p35 sig_type=std_logic lab=A14}
C {lab_pin.sym} 3920 -40 0 0 {name=p36 sig_type=std_logic lab=B14}
C {lab_pin.sym} 4130 -60 0 0 {name=p37 sig_type=std_logic lab=A15}
C {lab_pin.sym} 4130 -40 0 0 {name=p38 sig_type=std_logic lab=B15}
