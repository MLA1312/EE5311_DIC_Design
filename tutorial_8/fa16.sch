v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -40 -40 -10 -40 {lab=B0}
N -40 120 0 120 {lab=B0}
N -30 -60 -30 100 {lab=A0}
N -30 100 0 100 {lab=A0}
N -60 60 40 60 {lab=DVDD}
N -10 30 40 30 {lab=DGND}
N -10 30 -10 160 {lab=DGND}
N -10 160 40 160 {lab=DGND}
N -90 -60 -10 -60 {lab=A0}
N -70 -100 40 -100 {lab=DVDD}
N -70 -100 -70 60 {lab=DVDD}
N -70 60 -60 60 {lab=DVDD}
N -50 -40 -50 120 {lab=B0}
N -50 120 -40 120 {lab=B0}
N -90 -40 -40 -40 {lab=B0}
N 40 -100 140 -100 {lab=DVDD}
N 90 -30 90 -20 {lab=#net1}
N -140 -20 -10 -20 {lab=Cin}
N 40 160 220 160 {lab=DGND}
N 90 -20 130 -20 {lab=#net1}
N 170 -100 170 -60 {lab=DVDD}
N 140 -100 170 -100 {lab=DVDD}
N 170 20 170 160 {lab=DGND}
N 320 -40 350 -40 {lab=B1}
N 320 120 360 120 {lab=B1}
N 330 -60 330 100 {lab=A1}
N 330 100 360 100 {lab=A1}
N 300 60 400 60 {lab=DVDD}
N 350 30 400 30 {lab=DGND}
N 350 30 350 160 {lab=DGND}
N 350 160 400 160 {lab=DGND}
N 270 -60 350 -60 {lab=A1}
N 290 -100 400 -100 {lab=DVDD}
N 290 -100 290 60 {lab=DVDD}
N 290 60 300 60 {lab=DVDD}
N 310 -40 310 120 {lab=B1}
N 310 120 320 120 {lab=B1}
N 270 -40 320 -40 {lab=B1}
N 400 -100 500 -100 {lab=DVDD}
N 450 -30 450 -20 {lab=#net2}
N 220 -20 350 -20 {lab=#net3}
N 400 160 580 160 {lab=DGND}
N 450 -20 490 -20 {lab=#net2}
N 530 -100 530 -60 {lab=DVDD}
N 500 -100 530 -100 {lab=DVDD}
N 530 20 530 160 {lab=DGND}
N 220 160 350 160 {lab=DGND}
N 170 -100 290 -100 {lab=DVDD}
N 680 -40 710 -40 {lab=B2}
N 680 120 720 120 {lab=B2}
N 690 -60 690 100 {lab=A2}
N 690 100 720 100 {lab=A2}
N 660 60 760 60 {lab=DVDD}
N 710 30 760 30 {lab=DGND}
N 710 30 710 160 {lab=DGND}
N 710 160 760 160 {lab=DGND}
N 630 -60 710 -60 {lab=A2}
N 650 -100 760 -100 {lab=DVDD}
N 650 -100 650 60 {lab=DVDD}
N 650 60 660 60 {lab=DVDD}
N 670 -40 670 120 {lab=B2}
N 670 120 680 120 {lab=B2}
N 630 -40 680 -40 {lab=B2}
N 760 -100 860 -100 {lab=DVDD}
N 810 -30 810 -20 {lab=#net4}
N 580 -20 710 -20 {lab=#net5}
N 760 160 940 160 {lab=DGND}
N 810 -20 850 -20 {lab=#net4}
N 890 -100 890 -60 {lab=DVDD}
N 860 -100 890 -100 {lab=DVDD}
N 890 20 890 160 {lab=DGND}
N 1040 -40 1070 -40 {lab=B3}
N 1040 120 1080 120 {lab=B3}
N 1050 -60 1050 100 {lab=A3}
N 1050 100 1080 100 {lab=A3}
N 1020 60 1120 60 {lab=DVDD}
N 1070 30 1120 30 {lab=DGND}
N 1070 30 1070 160 {lab=DGND}
N 1070 160 1120 160 {lab=DGND}
N 990 -60 1070 -60 {lab=A3}
N 1010 -100 1120 -100 {lab=DVDD}
N 1010 -100 1010 60 {lab=DVDD}
N 1010 60 1020 60 {lab=DVDD}
N 1030 -40 1030 120 {lab=B3}
N 1030 120 1040 120 {lab=B3}
N 990 -40 1040 -40 {lab=B3}
N 1120 -100 1220 -100 {lab=DVDD}
N 1170 -30 1170 -20 {lab=#net6}
N 940 -20 1070 -20 {lab=#net7}
N 1170 -20 1210 -20 {lab=#net6}
N 1250 -100 1250 -60 {lab=DVDD}
N 1220 -100 1250 -100 {lab=DVDD}
N 1250 20 1250 160 {lab=DGND}
N 940 160 1070 160 {lab=DGND}
N 890 -100 1010 -100 {lab=DVDD}
N 530 -100 650 -100 {lab=DVDD}
N 580 160 710 160 {lab=DGND}
N 1120 160 1250 160 {lab=DGND}
N 1120 160 1120 230 {lab=DGND}
N 1120 230 1430 230 {lab=DGND}
N 810 190 1380 190 {lab=#net8}
N 810 110 810 190 {lab=#net8}
N 1170 110 1170 170 {lab=#net9}
N 1170 170 1380 170 {lab=#net9}
N 1310 150 1380 150 {lab=#net10}
N 1310 150 1310 210 {lab=#net10}
N 450 210 1310 210 {lab=#net10}
N 450 110 450 210 {lab=#net10}
N 1330 130 1380 130 {lab=#net11}
N 1330 130 1330 220 {lab=#net11}
N 90 220 1330 220 {lab=#net11}
N 90 110 90 220 {lab=#net11}
N 1120 60 1430 60 {lab=DVDD}
N 1430 60 1430 90 {lab=DVDD}
N 1490 160 1510 160 {lab=#net12}
N 1510 10 1510 160 {lab=#net12}
N 1300 -20 1470 -20 {lab=#net13}
N 1500 -100 1500 -70 {lab=DVDD}
N 1250 -100 1500 -100 {lab=DVDD}
N 1360 -60 1510 -60 {lab=DGND}
N 1360 -60 1360 20 {lab=DGND}
N 1250 20 1360 20 {lab=DGND}
N 1430 -40 1470 -40 {lab=Cin}
N 1690 -50 1720 -50 {lab=B4}
N 1690 110 1730 110 {lab=B4}
N 1700 -70 1700 90 {lab=A4}
N 1700 90 1730 90 {lab=A4}
N 1670 50 1770 50 {lab=DVDD}
N 1720 20 1770 20 {lab=DGND}
N 1720 20 1720 150 {lab=DGND}
N 1720 150 1770 150 {lab=DGND}
N 1640 -70 1720 -70 {lab=A4}
N 1660 -110 1770 -110 {lab=DVDD}
N 1660 -110 1660 50 {lab=DVDD}
N 1660 50 1670 50 {lab=DVDD}
N 1680 -50 1680 110 {lab=B4}
N 1680 110 1690 110 {lab=B4}
N 1640 -50 1690 -50 {lab=B4}
N 1770 -110 1870 -110 {lab=DVDD}
N 1820 -40 1820 -30 {lab=#net14}
N 1590 -30 1720 -30 {lab=C1}
N 1770 150 1950 150 {lab=DGND}
N 1820 -30 1860 -30 {lab=#net14}
N 1900 -110 1900 -70 {lab=DVDD}
N 1870 -110 1900 -110 {lab=DVDD}
N 1900 10 1900 150 {lab=DGND}
N 2050 -50 2080 -50 {lab=B5}
N 2050 110 2090 110 {lab=B5}
N 2060 -70 2060 90 {lab=A5}
N 2060 90 2090 90 {lab=A5}
N 2030 50 2130 50 {lab=DVDD}
N 2080 20 2130 20 {lab=DGND}
N 2080 20 2080 150 {lab=DGND}
N 2080 150 2130 150 {lab=DGND}
N 2000 -70 2080 -70 {lab=A5}
N 2020 -110 2130 -110 {lab=DVDD}
N 2020 -110 2020 50 {lab=DVDD}
N 2020 50 2030 50 {lab=DVDD}
N 2040 -50 2040 110 {lab=B5}
N 2040 110 2050 110 {lab=B5}
N 2000 -50 2050 -50 {lab=B5}
N 2130 -110 2230 -110 {lab=DVDD}
N 2180 -40 2180 -30 {lab=#net15}
N 1950 -30 2080 -30 {lab=#net16}
N 2130 150 2310 150 {lab=DGND}
N 2180 -30 2220 -30 {lab=#net15}
N 2260 -110 2260 -70 {lab=DVDD}
N 2230 -110 2260 -110 {lab=DVDD}
N 2260 10 2260 150 {lab=DGND}
N 1950 150 2080 150 {lab=DGND}
N 1900 -110 2020 -110 {lab=DVDD}
N 2410 -50 2440 -50 {lab=B6}
N 2410 110 2450 110 {lab=B6}
N 2420 -70 2420 90 {lab=A6}
N 2420 90 2450 90 {lab=A6}
N 2390 50 2490 50 {lab=DVDD}
N 2440 20 2490 20 {lab=DGND}
N 2440 20 2440 150 {lab=DGND}
N 2440 150 2490 150 {lab=DGND}
N 2360 -70 2440 -70 {lab=A6}
N 2380 -110 2490 -110 {lab=DVDD}
N 2380 -110 2380 50 {lab=DVDD}
N 2380 50 2390 50 {lab=DVDD}
N 2400 -50 2400 110 {lab=B6}
N 2400 110 2410 110 {lab=B6}
N 2360 -50 2410 -50 {lab=B6}
N 2490 -110 2590 -110 {lab=DVDD}
N 2540 -40 2540 -30 {lab=#net17}
N 2310 -30 2440 -30 {lab=#net18}
N 2490 150 2670 150 {lab=DGND}
N 2540 -30 2580 -30 {lab=#net17}
N 2620 -110 2620 -70 {lab=DVDD}
N 2590 -110 2620 -110 {lab=DVDD}
N 2620 10 2620 150 {lab=DGND}
N 2770 -50 2800 -50 {lab=B7}
N 2770 110 2810 110 {lab=B7}
N 2780 -70 2780 90 {lab=A7}
N 2780 90 2810 90 {lab=A7}
N 2750 50 2850 50 {lab=DVDD}
N 2800 20 2850 20 {lab=DGND}
N 2800 20 2800 150 {lab=DGND}
N 2800 150 2850 150 {lab=DGND}
N 2720 -70 2800 -70 {lab=A7}
N 2740 -110 2850 -110 {lab=DVDD}
N 2740 -110 2740 50 {lab=DVDD}
N 2740 50 2750 50 {lab=DVDD}
N 2760 -50 2760 110 {lab=B7}
N 2760 110 2770 110 {lab=B7}
N 2720 -50 2770 -50 {lab=B7}
N 2850 -110 2950 -110 {lab=DVDD}
N 2900 -40 2900 -30 {lab=#net19}
N 2670 -30 2800 -30 {lab=#net20}
N 2900 -30 2940 -30 {lab=#net19}
N 2980 -110 2980 -70 {lab=DVDD}
N 2950 -110 2980 -110 {lab=DVDD}
N 2980 10 2980 150 {lab=DGND}
N 2670 150 2800 150 {lab=DGND}
N 2620 -110 2740 -110 {lab=DVDD}
N 2260 -110 2380 -110 {lab=DVDD}
N 2310 150 2440 150 {lab=DGND}
N 2850 150 2980 150 {lab=DGND}
N 2850 150 2850 220 {lab=DGND}
N 2850 220 3160 220 {lab=DGND}
N 2540 180 3110 180 {lab=#net21}
N 2540 100 2540 180 {lab=#net21}
N 2900 100 2900 160 {lab=#net22}
N 2900 160 3110 160 {lab=#net22}
N 3040 140 3110 140 {lab=#net23}
N 3040 140 3040 200 {lab=#net23}
N 2180 200 3040 200 {lab=#net23}
N 2180 100 2180 200 {lab=#net23}
N 3060 120 3110 120 {lab=#net24}
N 3060 120 3060 210 {lab=#net24}
N 1820 210 3060 210 {lab=#net24}
N 1820 100 1820 210 {lab=#net24}
N 2850 50 3160 50 {lab=DVDD}
N 3160 50 3160 80 {lab=DVDD}
N 3220 150 3240 150 {lab=#net25}
N 3240 0 3240 150 {lab=#net25}
N 3030 -30 3200 -30 {lab=#net26}
N 3230 -110 3230 -80 {lab=DVDD}
N 2980 -110 3230 -110 {lab=DVDD}
N 3090 -70 3240 -70 {lab=DGND}
N 3090 -70 3090 10 {lab=DGND}
N 2980 10 3090 10 {lab=DGND}
N 3160 -50 3200 -50 {lab=C1}
N 1540 -30 1590 -30 {lab=C1}
N 1500 -100 1660 -100 {lab=DVDD}
N 1770 150 1770 230 {lab=DGND}
N 1430 230 1770 230 {lab=DGND}
N 3370 -60 3400 -60 {lab=B8}
N 3370 100 3410 100 {lab=B8}
N 3380 -80 3380 80 {lab=A8}
N 3380 80 3410 80 {lab=A8}
N 3350 40 3450 40 {lab=DVDD}
N 3400 10 3450 10 {lab=DGND}
N 3400 10 3400 140 {lab=DGND}
N 3400 140 3450 140 {lab=DGND}
N 3320 -80 3400 -80 {lab=A8}
N 3340 -120 3450 -120 {lab=DVDD}
N 3340 -120 3340 40 {lab=DVDD}
N 3340 40 3350 40 {lab=DVDD}
N 3360 -60 3360 100 {lab=B8}
N 3360 100 3370 100 {lab=B8}
N 3320 -60 3370 -60 {lab=B8}
N 3450 -120 3550 -120 {lab=DVDD}
N 3500 -50 3500 -40 {lab=#net27}
N 3450 140 3630 140 {lab=DGND}
N 3500 -40 3540 -40 {lab=#net27}
N 3580 -120 3580 -80 {lab=DVDD}
N 3550 -120 3580 -120 {lab=DVDD}
N 3580 0 3580 140 {lab=DGND}
N 3730 -60 3760 -60 {lab=B9}
N 3730 100 3770 100 {lab=B9}
N 3740 -80 3740 80 {lab=A9}
N 3740 80 3770 80 {lab=A9}
N 3710 40 3810 40 {lab=DVDD}
N 3760 10 3810 10 {lab=DGND}
N 3760 10 3760 140 {lab=DGND}
N 3760 140 3810 140 {lab=DGND}
N 3680 -80 3760 -80 {lab=A9}
N 3700 -120 3810 -120 {lab=DVDD}
N 3700 -120 3700 40 {lab=DVDD}
N 3700 40 3710 40 {lab=DVDD}
N 3720 -60 3720 100 {lab=B9}
N 3720 100 3730 100 {lab=B9}
N 3680 -60 3730 -60 {lab=B9}
N 3810 -120 3910 -120 {lab=DVDD}
N 3860 -50 3860 -40 {lab=#net28}
N 3630 -40 3760 -40 {lab=#net29}
N 3810 140 3990 140 {lab=DGND}
N 3860 -40 3900 -40 {lab=#net28}
N 3940 -120 3940 -80 {lab=DVDD}
N 3910 -120 3940 -120 {lab=DVDD}
N 3940 0 3940 140 {lab=DGND}
N 3630 140 3760 140 {lab=DGND}
N 3580 -120 3700 -120 {lab=DVDD}
N 4090 -60 4120 -60 {lab=B10}
N 4090 100 4130 100 {lab=B10}
N 4100 -80 4100 80 {lab=A10}
N 4100 80 4130 80 {lab=A10}
N 4070 40 4170 40 {lab=DVDD}
N 4120 10 4170 10 {lab=DGND}
N 4120 10 4120 140 {lab=DGND}
N 4120 140 4170 140 {lab=DGND}
N 4040 -80 4120 -80 {lab=A10}
N 4060 -120 4170 -120 {lab=DVDD}
N 4060 -120 4060 40 {lab=DVDD}
N 4060 40 4070 40 {lab=DVDD}
N 4080 -60 4080 100 {lab=B10}
N 4080 100 4090 100 {lab=B10}
N 4040 -60 4090 -60 {lab=B10}
N 4170 -120 4270 -120 {lab=DVDD}
N 4220 -50 4220 -40 {lab=#net30}
N 3990 -40 4120 -40 {lab=#net31}
N 4170 140 4350 140 {lab=DGND}
N 4220 -40 4260 -40 {lab=#net30}
N 4300 -120 4300 -80 {lab=DVDD}
N 4270 -120 4300 -120 {lab=DVDD}
N 4300 0 4300 140 {lab=DGND}
N 4450 -60 4480 -60 {lab=B11}
N 4450 100 4490 100 {lab=B11}
N 4460 -80 4460 80 {lab=A11}
N 4460 80 4490 80 {lab=A11}
N 4430 40 4530 40 {lab=DVDD}
N 4480 10 4530 10 {lab=DGND}
N 4480 10 4480 140 {lab=DGND}
N 4480 140 4530 140 {lab=DGND}
N 4400 -80 4480 -80 {lab=A11}
N 4420 -120 4530 -120 {lab=DVDD}
N 4420 -120 4420 40 {lab=DVDD}
N 4420 40 4430 40 {lab=DVDD}
N 4440 -60 4440 100 {lab=B11}
N 4440 100 4450 100 {lab=B11}
N 4400 -60 4450 -60 {lab=B11}
N 4530 -120 4630 -120 {lab=DVDD}
N 4580 -50 4580 -40 {lab=#net32}
N 4350 -40 4480 -40 {lab=#net33}
N 4580 -40 4620 -40 {lab=#net32}
N 4660 -120 4660 -80 {lab=DVDD}
N 4630 -120 4660 -120 {lab=DVDD}
N 4660 0 4660 140 {lab=DGND}
N 4350 140 4480 140 {lab=DGND}
N 4300 -120 4420 -120 {lab=DVDD}
N 3940 -120 4060 -120 {lab=DVDD}
N 3990 140 4120 140 {lab=DGND}
N 4530 140 4660 140 {lab=DGND}
N 4530 140 4530 210 {lab=DGND}
N 4530 210 4840 210 {lab=DGND}
N 4220 170 4790 170 {lab=#net34}
N 4220 90 4220 170 {lab=#net34}
N 4580 90 4580 150 {lab=#net35}
N 4580 150 4790 150 {lab=#net35}
N 4720 130 4790 130 {lab=#net36}
N 4720 130 4720 190 {lab=#net36}
N 3860 190 4720 190 {lab=#net36}
N 3860 90 3860 190 {lab=#net36}
N 4740 110 4790 110 {lab=#net37}
N 4740 110 4740 200 {lab=#net37}
N 3500 200 4740 200 {lab=#net37}
N 3500 90 3500 200 {lab=#net37}
N 4530 40 4840 40 {lab=DVDD}
N 4840 40 4840 70 {lab=DVDD}
N 4900 140 4920 140 {lab=#net38}
N 4920 -10 4920 140 {lab=#net38}
N 4710 -40 4880 -40 {lab=#net39}
N 4910 -120 4910 -90 {lab=DVDD}
N 4660 -120 4910 -120 {lab=DVDD}
N 4770 -80 4920 -80 {lab=DGND}
N 4770 -80 4770 0 {lab=DGND}
N 4660 0 4770 0 {lab=DGND}
N 4840 -60 4880 -60 {lab=C2}
N 5100 -70 5130 -70 {lab=B12}
N 5100 90 5140 90 {lab=B12}
N 5110 -90 5110 70 {lab=A12}
N 5110 70 5140 70 {lab=A12}
N 5080 30 5180 30 {lab=DVDD}
N 5130 0 5180 0 {lab=DGND}
N 5130 0 5130 130 {lab=DGND}
N 5130 130 5180 130 {lab=DGND}
N 5050 -90 5130 -90 {lab=A12}
N 5070 -130 5180 -130 {lab=DVDD}
N 5070 -130 5070 30 {lab=DVDD}
N 5070 30 5080 30 {lab=DVDD}
N 5090 -70 5090 90 {lab=B12}
N 5090 90 5100 90 {lab=B12}
N 5050 -70 5100 -70 {lab=B12}
N 5180 -130 5280 -130 {lab=DVDD}
N 5230 -60 5230 -50 {lab=#net40}
N 5000 -50 5130 -50 {lab=C3}
N 5180 130 5360 130 {lab=DGND}
N 5230 -50 5270 -50 {lab=#net40}
N 5310 -130 5310 -90 {lab=DVDD}
N 5280 -130 5310 -130 {lab=DVDD}
N 5310 -10 5310 130 {lab=DGND}
N 5460 -70 5490 -70 {lab=B13}
N 5460 90 5500 90 {lab=B13}
N 5470 -90 5470 70 {lab=A13}
N 5470 70 5500 70 {lab=A13}
N 5440 30 5540 30 {lab=DVDD}
N 5490 0 5540 0 {lab=DGND}
N 5490 0 5490 130 {lab=DGND}
N 5490 130 5540 130 {lab=DGND}
N 5410 -90 5490 -90 {lab=A13}
N 5430 -130 5540 -130 {lab=DVDD}
N 5430 -130 5430 30 {lab=DVDD}
N 5430 30 5440 30 {lab=DVDD}
N 5450 -70 5450 90 {lab=B13}
N 5450 90 5460 90 {lab=B13}
N 5410 -70 5460 -70 {lab=B13}
N 5540 -130 5640 -130 {lab=DVDD}
N 5590 -60 5590 -50 {lab=#net41}
N 5360 -50 5490 -50 {lab=#net42}
N 5540 130 5720 130 {lab=DGND}
N 5590 -50 5630 -50 {lab=#net41}
N 5670 -130 5670 -90 {lab=DVDD}
N 5640 -130 5670 -130 {lab=DVDD}
N 5670 -10 5670 130 {lab=DGND}
N 5360 130 5490 130 {lab=DGND}
N 5310 -130 5430 -130 {lab=DVDD}
N 5820 -70 5850 -70 {lab=B14}
N 5820 90 5860 90 {lab=B14}
N 5830 -90 5830 70 {lab=A14}
N 5830 70 5860 70 {lab=A14}
N 5800 30 5900 30 {lab=DVDD}
N 5850 0 5900 0 {lab=DGND}
N 5850 0 5850 130 {lab=DGND}
N 5850 130 5900 130 {lab=DGND}
N 5770 -90 5850 -90 {lab=A14}
N 5790 -130 5900 -130 {lab=DVDD}
N 5790 -130 5790 30 {lab=DVDD}
N 5790 30 5800 30 {lab=DVDD}
N 5810 -70 5810 90 {lab=B14}
N 5810 90 5820 90 {lab=B14}
N 5770 -70 5820 -70 {lab=B14}
N 5900 -130 6000 -130 {lab=DVDD}
N 5950 -60 5950 -50 {lab=#net43}
N 5720 -50 5850 -50 {lab=#net44}
N 5900 130 6080 130 {lab=DGND}
N 5950 -50 5990 -50 {lab=#net43}
N 6030 -130 6030 -90 {lab=DVDD}
N 6000 -130 6030 -130 {lab=DVDD}
N 6030 -10 6030 130 {lab=DGND}
N 6180 -70 6210 -70 {lab=B15}
N 6180 90 6220 90 {lab=B15}
N 6190 -90 6190 70 {lab=A15}
N 6190 70 6220 70 {lab=A15}
N 6160 30 6260 30 {lab=DVDD}
N 6210 0 6260 0 {lab=DGND}
N 6210 0 6210 130 {lab=DGND}
N 6210 130 6260 130 {lab=DGND}
N 6130 -90 6210 -90 {lab=A15}
N 6150 -130 6260 -130 {lab=DVDD}
N 6150 -130 6150 30 {lab=DVDD}
N 6150 30 6160 30 {lab=DVDD}
N 6170 -70 6170 90 {lab=B15}
N 6170 90 6180 90 {lab=B15}
N 6130 -70 6180 -70 {lab=B15}
N 6260 -130 6360 -130 {lab=DVDD}
N 6310 -60 6310 -50 {lab=#net45}
N 6080 -50 6210 -50 {lab=#net46}
N 6310 -50 6350 -50 {lab=#net45}
N 6390 -130 6390 -90 {lab=DVDD}
N 6360 -130 6390 -130 {lab=DVDD}
N 6390 -10 6390 130 {lab=DGND}
N 6080 130 6210 130 {lab=DGND}
N 6030 -130 6150 -130 {lab=DVDD}
N 5670 -130 5790 -130 {lab=DVDD}
N 5720 130 5850 130 {lab=DGND}
N 6260 130 6390 130 {lab=DGND}
N 6260 130 6260 200 {lab=DGND}
N 6260 200 6570 200 {lab=DGND}
N 5950 160 6520 160 {lab=#net47}
N 5950 80 5950 160 {lab=#net47}
N 6310 80 6310 140 {lab=#net48}
N 6310 140 6520 140 {lab=#net48}
N 6450 120 6520 120 {lab=#net49}
N 6450 120 6450 180 {lab=#net49}
N 5590 180 6450 180 {lab=#net49}
N 5590 80 5590 180 {lab=#net49}
N 6470 100 6520 100 {lab=#net50}
N 6470 100 6470 190 {lab=#net50}
N 5230 190 6470 190 {lab=#net50}
N 5230 80 5230 190 {lab=#net50}
N 6260 30 6570 30 {lab=DVDD}
N 6570 30 6570 60 {lab=DVDD}
N 6630 130 6650 130 {lab=#net51}
N 6650 -20 6650 130 {lab=#net51}
N 6440 -50 6610 -50 {lab=#net52}
N 6640 -130 6640 -100 {lab=DVDD}
N 6390 -130 6640 -130 {lab=DVDD}
N 6500 -90 6650 -90 {lab=DGND}
N 6500 -90 6500 -10 {lab=DGND}
N 6390 -10 6500 -10 {lab=DGND}
N 6570 -70 6610 -70 {lab=C3}
N 4950 -50 5000 -50 {lab=C3}
N 4910 -120 5070 -120 {lab=DVDD}
N 5180 130 5180 210 {lab=DGND}
N 4840 210 5180 210 {lab=DGND}
N 3270 -40 3400 -40 {lab=C2}
N 3230 -110 3340 -110 {lab=DVDD}
N 3400 140 3400 220 {lab=DGND}
N 3160 220 3400 220 {lab=DGND}
N 6310 -80 6320 -80 {lab=#net53}
N 6320 -190 6320 -80 {lab=#net53}
N 6320 -190 6350 -190 {lab=#net53}
N 6210 -230 6210 -130 {lab=DVDD}
N 6210 -230 6390 -230 {lab=DVDD}
N 6340 -150 6390 -150 {lab=DGND}
N 6340 -150 6340 -0 {lab=DGND}
N 6260 -0 6340 -0 {lab=DGND}
N 6440 -190 6470 -190 {lab=S15}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 140 -30 0 0 {name=x1}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 150 120 0 0 {name=x6}
C {ipin.sym} -90 -60 0 0 {name=p1 lab=A0}
C {ipin.sym} -90 -40 0 0 {name=p2 lab=B0}
C {ipin.sym} -140 -20 0 0 {name=p3 lab=Cin}
C {inv.sym} 280 -20 0 0 {name=x2}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 500 -30 0 0 {name=x3}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 510 120 0 0 {name=x4}
C {ipin.sym} 270 -60 0 0 {name=p4 lab=A1}
C {ipin.sym} 270 -40 0 0 {name=p5 lab=B1}
C {inv.sym} 640 -20 0 0 {name=x5}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 860 -30 0 0 {name=x7}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 870 120 0 0 {name=x8}
C {ipin.sym} 630 -60 0 0 {name=p6 lab=A2}
C {ipin.sym} 630 -40 0 0 {name=p7 lab=B2}
C {inv.sym} 1000 -20 0 0 {name=x9}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 1220 -30 0 0 {name=x10}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 1230 120 0 0 {name=x11}
C {ipin.sym} 990 -60 0 0 {name=p8 lab=A3}
C {ipin.sym} 990 -40 0 0 {name=p9 lab=B3}
C {inv.sym} 1360 -20 0 0 {name=x12}
C {nand4.sym} 1530 160 0 0 {name=x13}
C {mux2.sym} 1620 -40 0 0 {name=x14}
C {lab_pin.sym} 1430 -40 0 0 {name=p10 sig_type=std_logic lab=Cin}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 1870 -40 0 0 {name=x15}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 1880 110 0 0 {name=x16}
C {ipin.sym} 1640 -70 0 0 {name=p11 lab=A4}
C {ipin.sym} 1640 -50 0 0 {name=p12 lab=B4}
C {inv.sym} 2010 -30 0 0 {name=x17}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 2230 -40 0 0 {name=x18}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 2240 110 0 0 {name=x19}
C {ipin.sym} 2000 -70 0 0 {name=p14 lab=A5}
C {ipin.sym} 2000 -50 0 0 {name=p15 lab=B5}
C {inv.sym} 2370 -30 0 0 {name=x20}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 2590 -40 0 0 {name=x21}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 2600 110 0 0 {name=x22}
C {ipin.sym} 2360 -70 0 0 {name=p16 lab=A6}
C {ipin.sym} 2360 -50 0 0 {name=p17 lab=B6}
C {inv.sym} 2730 -30 0 0 {name=x23}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 2950 -40 0 0 {name=x24}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 2960 110 0 0 {name=x25}
C {ipin.sym} 2720 -70 0 0 {name=p18 lab=A7}
C {ipin.sym} 2720 -50 0 0 {name=p19 lab=B7}
C {inv.sym} 3090 -30 0 0 {name=x26}
C {nand4.sym} 3260 150 0 0 {name=x27}
C {mux2.sym} 3350 -50 0 0 {name=x28}
C {lab_pin.sym} 3160 -50 0 0 {name=p20 sig_type=std_logic lab=C1}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 3550 -50 0 0 {name=x29}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 3560 100 0 0 {name=x30}
C {ipin.sym} 3320 -80 0 0 {name=p13 lab=A8}
C {ipin.sym} 3320 -60 0 0 {name=p21 lab=B8}
C {inv.sym} 3690 -40 0 0 {name=x31}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 3910 -50 0 0 {name=x32}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 3920 100 0 0 {name=x33}
C {ipin.sym} 3680 -80 0 0 {name=p22 lab=A9}
C {ipin.sym} 3680 -60 0 0 {name=p23 lab=B9}
C {inv.sym} 4050 -40 0 0 {name=x34}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 4270 -50 0 0 {name=x35}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 4280 100 0 0 {name=x36}
C {ipin.sym} 4040 -80 0 0 {name=p24 lab=A10}
C {ipin.sym} 4040 -60 0 0 {name=p25 lab=B10}
C {inv.sym} 4410 -40 0 0 {name=x37}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 4630 -50 0 0 {name=x38}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 4640 100 0 0 {name=x39}
C {ipin.sym} 4400 -80 0 0 {name=p26 lab=A11}
C {ipin.sym} 4400 -60 0 0 {name=p27 lab=B11}
C {inv.sym} 4770 -40 0 0 {name=x40}
C {nand4.sym} 4940 140 0 0 {name=x41}
C {mux2.sym} 5030 -60 0 0 {name=x42}
C {lab_pin.sym} 4840 -60 0 0 {name=p28 sig_type=std_logic lab=C2}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 5280 -60 0 0 {name=x43}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 5290 90 0 0 {name=x44}
C {ipin.sym} 5050 -90 0 0 {name=p29 lab=A12}
C {ipin.sym} 5050 -70 0 0 {name=p30 lab=B12}
C {inv.sym} 5420 -50 0 0 {name=x45}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 5640 -60 0 0 {name=x46}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 5650 90 0 0 {name=x47}
C {ipin.sym} 5410 -90 0 0 {name=p31 lab=A13}
C {ipin.sym} 5410 -70 0 0 {name=p32 lab=B13}
C {inv.sym} 5780 -50 0 0 {name=x48}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 6000 -60 0 0 {name=x49}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 6010 90 0 0 {name=x50}
C {ipin.sym} 5770 -90 0 0 {name=p33 lab=A14}
C {ipin.sym} 5770 -70 0 0 {name=p34 lab=B14}
C {inv.sym} 6140 -50 0 0 {name=x51}
C {/home/EE23B038/ee5311/tutorial_8/fa.sym} 6360 -60 0 0 {name=x52}
C {/home/EE23B038/ee5311/tutorial_8/xor2.sym} 6370 90 0 0 {name=x53}
C {ipin.sym} 6130 -90 0 0 {name=p35 lab=A15}
C {ipin.sym} 6130 -70 0 0 {name=p36 lab=B15}
C {inv.sym} 6500 -50 0 0 {name=x54}
C {nand4.sym} 6670 130 0 0 {name=x55}
C {mux2.sym} 6760 -70 0 0 {name=x56}
C {lab_pin.sym} 6570 -70 0 0 {name=p37 sig_type=std_logic lab=C3}
C {iopin.sym} 3400 220 1 0 {name=p39 lab=DGND}
C {iopin.sym} 3350 -120 3 0 {name=p40 lab=DVDD}
C {lab_pin.sym} 1570 -30 3 0 {name=p41 sig_type=std_logic lab=C1}
C {lab_pin.sym} 3290 -40 3 0 {name=p42 sig_type=std_logic lab=C2}
C {lab_pin.sym} 4970 -50 3 0 {name=p43 sig_type=std_logic lab=C3}
C {inv.sym} 6500 -190 0 0 {name=x57}
C {opin.sym} 6470 -190 0 0 {name=p38 lab=S15}
